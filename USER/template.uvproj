# Keil uVision project template.uvproj, settings and files
target TEMPLATE (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: .\1.bat
  c flags: Optimize=9
  c include: ..\USER;..\FUNC_HANDLER;..\GUI_APP
  link misc: REMOVEUNUSED
  group USER
    ./: STARTUP_M5.A51 main.c sys.c crc16.c i2c.c Uart.c Uart.h Parameter_Config.h crc16.h T5LLIB.C module.c mb_user.c mb_user.h
  group modbus
    ./: mb_crc.c mb_crc.h mb_hook.c mb_hook.h mb_host.c mb_host.h mb_include.h mb_port.c mb_port.h
  group nor_flash
    ./: nor_flash.c nor_flash.h
  group scene
    ./: scene.c scene.h time_scene.c time_scene.h
  group touch_panel
    ./: touch_panel.c touch_panel.h
